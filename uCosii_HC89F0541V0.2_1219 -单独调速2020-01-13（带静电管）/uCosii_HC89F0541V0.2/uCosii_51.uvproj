# Keil uVision project uCosii_51.uvproj, settings and files
target Target 1 (MCS-51)
  device: HC89F0541 HolyChip
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x7FFF) CLOCK(32000000)
  output: uCosii_51 +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: .\Source;.\uCosii
  group User
    ./Source/: main.c task1.c task2.c task3.c task1.h
    ./: remade.txt
  group uCosii
    ./uCosii/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c os_cpu_c.c os_cpu_a.asm
    ./: STARTUP.A51
